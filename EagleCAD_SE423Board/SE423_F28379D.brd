# Repository sinpran/Mechatronics

File README.md:

# LabRepo
Lab Repository for SE423 Labs and Assignments

## EAGLE design EagleCAD_SE423Board/SE423_F28379D.brd

Parts:
3V3, 5V: LEDCHIPLED_1206; CHIPLED_1206
DCDC3.3V, DCDC5V: PINHD-1X3; 1X03
J5: JACK-PMS
J10, J14, J15, J16, J17, J18, J19, J20, J21, J28, J29, J30, J31, J32, J33, J98, J99, J100, J101, J102, J103, J104, J105, J106, J107, J108, J109, J110, J111, J112, J113, J114, J115, J116, J117, J118, J119, J120, J121, J122, J123, J124, J125, J126, J127, J128, J129, J130, J131, J132, J133, J134, J135, J136, J137, J138, J139, J140, J141, J142, J143, J144, J145, J146, J147, J148, J149, J150, J151, J152, J153, J154, J155, J156, J157, J158, J159, J160, J161, J162, J163, J164, J165, J166, J167, J168, J169, J170, J176, J177: STRIP3
J204, J205, J206, J207, J251: STRIP2
L1: F28379D_LAUNCHPAD
POWER: PINHD-1X2; 1X02
R26, R27: 470; M1206
S141: STRIP5
U$1: MPU-9250-BB

Connections:
+5V: DCDC5V.3, J103.P$1, J103.P$2, J103.P$3, J152.P$1, J152.P$2, J152.P$3, L1.P$21 (5V_1), L1.P$61 (5V_2), R26.2; also elsewhere on the board
ADCIN14: J105.P$1, J105.P$2, J105.P$3, L1.P$23 (ADCIN14)
ADCIN15: J150.P$1, J150.P$2, J150.P$3, L1.P$63 (ADCIN15)
ADCINA2: J111.P$1, J111.P$2, J111.P$3, L1.P$29 (ADCINA2); also elsewhere on the board
ADCINA3: J108.P$1, J108.P$2, J108.P$3, L1.P$26 (ADCINA3); also elsewhere on the board
ADCINA4: J144.P$1, J144.P$2, J144.P$3, L1.P$69 (ADCINA4)
ADCINA5: J147.P$1, J147.P$2, J147.P$3, L1.P$66 (ADCINA5)
ADCINB2: J110.P$1, J110.P$2, J110.P$3, L1.P$28 (ADCINB2)
ADCINB3: J107.P$1, J107.P$2, J107.P$3, L1.P$25 (ADCINB3)
ADCINB4: J145.P$1, J145.P$2, J145.P$3, L1.P$68 (ADCINB4); also elsewhere on the board
ADCINB5: J148.P$1, J148.P$2, J148.P$3, L1.P$65 (ADCINB5)
ADCINC2: J109.P$1, J109.P$2, J109.P$3, L1.P$27 (ADCINC2)
ADCINC3: J106.P$1, J106.P$2, J106.P$3, L1.P$24 (ADCINC3)
ADCINC4: J146.P$1, J146.P$2, J146.P$3, L1.P$67 (ADCINC4)
ADCINC5: J149.P$1, J149.P$2, J149.P$3, L1.P$64 (ADCINC5)
DACOUTA: J112.P$1, J112.P$2, J112.P$3, L1.P$30 (ADCINA0/DACOUTA)
DACOUTB: J143.P$1, J143.P$2, J143.P$3, L1.P$70 (ADCINA1/DACOUTB)
GND: 3V3.C, 5V.C, DCDC3.3V.2, DCDC5V.2, J5.2, J5.3, J102.P$1, J102.P$2, J102.P$3, J104.P$1, J104.P$2, J104.P$3, J124.P$1, J124.P$2, J124.P$3, J151.P$1, J151.P$2, J151.P$3, J153.P$1, J153.P$2, J153.P$3, L1.P$20 (GND_1), L1.P$22 (GND_2), L1.P$60 (GND_3), L1.P$62 (GND_4), POWER.1, U$1.2 (P2_GND); also elsewhere on the board
GPIO0: J122.P$1, J122.P$2, J122.P$3, L1.P$40 (GPIO0/EPWM1A); also elsewhere on the board
GPIO1: J121.P$1, J121.P$2, J121.P$3, L1.P$39 (GPIO1/EPWM1B); also elsewhere on the board
GPIO2: J120.P$1, J120.P$2, J120.P$3, L1.P$38 (GPIO2/EPWM2A); also elsewhere on the board
GPIO3: J119.P$1, J119.P$2, J119.P$3, L1.P$37 (GPIO3/EPWM2B); also elsewhere on the board
GPIO4: J118.P$1, J118.P$2, J118.P$3, L1.P$36 (GPIO4/EPWM3A); also elsewhere on the board
GPIO5: J117.P$1, J117.P$2, J117.P$3, L1.P$35 (GPIO5/EPWM3B); also elsewhere on the board
GPIO6: J133.P$1, J133.P$2, J133.P$3, L1.P$80 (GPIO6/EPWM4A); also elsewhere on the board
GPIO7: J134.P$1, J134.P$2, J134.P$3, L1.P$79 (GPIO7/EPWM4B); also elsewhere on the board
GPIO8: J135.P$1, J135.P$2, J135.P$3, L1.P$78 (GPIO8/EPWM5A); also elsewhere on the board
GPIO9: J136.P$1, J136.P$2, J136.P$3, L1.P$77 (GPIO9/EPWM5B)
GPIO10: J137.P$1, J137.P$2, J137.P$3, L1.P$76 (GPIO10/EPWM6A); also elsewhere on the board
GPIO11: J138.P$1, J138.P$2, J138.P$3, L1.P$75 (GPIO11/EPWM6B); also elsewhere on the board
GPIO14: J139.P$1, J139.P$2, J139.P$3, L1.P$74 (GPIO14); also elsewhere on the board
GPIO15: J140.P$1, J140.P$2, J140.P$3, L1.P$73 (GPIO15); also elsewhere on the board
GPIO16: J115.P$1, J115.P$2, J115.P$3, J251.P$1, J251.P$2, L1.P$33 (GPIO16)
GPIO18: J16.P$1, J16.P$2, J16.P$3, L1.P$4 (GPIO18/SCITXDB); also elsewhere on the board
GPIO19: J15.P$1, J15.P$2, J15.P$3, L1.P$3 (GPIO19/SCIRXDB); also elsewhere on the board
GPIO22: J20.P$1, J20.P$2, J20.P$3, L1.P$8 (GPIO22); also elsewhere on the board
GPIO24: J116.P$1, J116.P$2, J116.P$3, L1.P$34 (GPIO24); also elsewhere on the board
GPIO25: J162.P$1, J162.P$2, J162.P$3, L1.P$51 (GPIO25); also elsewhere on the board
GPIO26: J160.P$1, J160.P$2, J160.P$3, L1.P$53 (GPIO26); also elsewhere on the board
GPIO27: J161.P$1, J161.P$2, J161.P$3, L1.P$52 (GPIO27); also elsewhere on the board
GPIO29: J29.P$1, J29.P$2, J29.P$3, L1.P$11 (GPIO29); also elsewhere on the board
GPIO32: J14.P$1, J14.P$2, J14.P$3, L1.P$2 (GPIO32); also elsewhere on the board
GPIO40: J163.P$1, J163.P$2, J163.P$3, L1.P$50 (GPIO40/SDAB); also elsewhere on the board
GPIO41: J164.P$1, J164.P$2, J164.P$3, L1.P$49 (GPIO41/SCLB); also elsewhere on the board
GPIO52: J165.P$1, J165.P$2, J165.P$3, L1.P$48 (GPIO52)
GPIO56: J169.P$1, J169.P$2, J169.P$3, L1.P$44 (GPIO56/SCITXDC); also elsewhere on the board
GPIO58: J33.P$1, J33.P$2, J33.P$3, L1.P$15 (GPIO58/SPISIMOA); also elsewhere on the board
GPIO59: J32.P$1, J32.P$2, J32.P$3, L1.P$14 (GPIO59/SPISOMIA); also elsewhere on the board
GPIO60: J19.P$1, J19.P$2, J19.P$3, L1.P$7 (GPIO60/SPICLKA); also elsewhere on the board
GPIO61: J101.P$1, J101.P$2, J101.P$3, L1.P$19 (GPIO61); also elsewhere on the board
GPIO63: J158.P$1, J158.P$2, J158.P$3, J204.P$1, J204.P$2, L1.P$55 (GPIO63/SPISIMOB)
GPIO64: J159.P$1, J159.P$2, J159.P$3, J205.P$1, J205.P$2, L1.P$54 (GPIO64/SPISOMIB)
GPIO65: J166.P$1, J166.P$2, J166.P$3, J206.P$1, J206.P$2, L1.P$47 (GPIO65/SPICLKB)
GPIO66: J154.P$1, J154.P$2, J154.P$3, J207.P$1, J207.P$2, L1.P$59 (GPIO66)
GPIO67: J17.P$1, J17.P$2, J17.P$3, L1.P$5 (GPIO67)
GPIO94: J167.P$1, J167.P$2, J167.P$3, L1.P$46 (GPIO94); also elsewhere on the board
GPIO95: J176.P$1, J176.P$2, J176.P$3, L1.P$42 (GPIO95); also elsewhere on the board
GPIO97: J168.P$1, J168.P$2, J168.P$3, L1.P$45 (GPIO97); also elsewhere on the board
GPIO104: J28.P$1, J28.P$2, J28.P$3, L1.P$10 (GPIO104/SDAA)
GPIO105: J21.P$1, J21.P$2, J21.P$3, L1.P$9 (GPIO105/SCLA)
GPIO111: J18.P$1, J18.P$2, J18.P$3, L1.P$6 (GPIO111); also elsewhere on the board
GPIO122: J99.P$1, J99.P$2, J99.P$3, L1.P$17 (GPIO122); also elsewhere on the board
GPIO123: J100.P$1, J100.P$2, J100.P$3, L1.P$18 (GPIO123); also elsewhere on the board
GPIO124: J31.P$1, J31.P$2, J31.P$3, L1.P$13 (GPIO124); also elsewhere on the board
GPIO125: J30.P$1, J30.P$2, J30.P$3, L1.P$12 (GPIO125); also elsewhere on the board
GPIO130: J156.P$1, J156.P$2, J156.P$3, L1.P$57 (GPIO130); also elsewhere on the board
GPIO131: J155.P$1, J155.P$2, J155.P$3, L1.P$58 (GPIO131); also elsewhere on the board
GPIO139: J170.P$1, J170.P$2, J170.P$3, L1.P$43 (GPIO139/SCIRXDC); also elsewhere on the board
GPIO157: J141.P$1, J141.P$2, J141.P$3, L1.P$72 (DAC3); also elsewhere on the board
GPIO158: J142.P$1, J142.P$2, J142.P$3, L1.P$71 (DAC4); also elsewhere on the board
GPIO159: J114.P$1, J114.P$2, J114.P$3, L1.P$32 (DAC1); also elsewhere on the board
GPIO160: J113.P$1, J113.P$2, J113.P$3, L1.P$31 (DAC2); also elsewhere on the board
unnamed: 3V3.A, R27.1
unnamed: 5V.A, R26.1
unnamed: J125.P$1, J125.P$2, J125.P$3, U$1.3 (P3_SCLK)
unnamed: J126.P$1, J126.P$2, J126.P$3, U$1.4 (P4_SDA/SPIMOSI)
unnamed: J127.P$1, J127.P$2, J127.P$3, U$1.5 (P5_EDA/AUX-DA)
unnamed: J128.P$1, J128.P$2, J128.P$3, U$1.6 (P6_ECL/AUX-CL)
unnamed: J129.P$1, J129.P$2, J129.P$3, U$1.7 (P7_ADO/SPIMISO)
unnamed: J130.P$1, J130.P$2, J130.P$3, U$1.8 (P8_INT)
unnamed: J131.P$1, J131.P$2, J131.P$3, U$1.9 (P9_NCS)
unnamed: J132.P$1, J132.P$2, J132.P$3, U$1.10 (P10_FSYNC)
POWER: DCDC3.3V.1, DCDC5V.1, J5.1, POWER.2, S141.P$1, S141.P$2, S141.P$3, S141.P$4, S141.P$5; also elsewhere on the board
RESET: J98.P$1, J98.P$2, J98.P$3, L1.P$16 (RST)
RESET_2: J157.P$1, J157.P$2, J157.P$3, L1.P$56 (RST_2)
VCC: DCDC3.3V.3, J10.P$1, J10.P$2, J10.P$3, J123.P$1, J123.P$2, J123.P$3, J177.P$1, J177.P$2, J177.P$3, L1.P$1 (3.3V_1), L1.P$41 (3.3V_2), R27.2, U$1.1 (P1_VCC); also elsewhere on the board

Notes on the sheet:
This is for the Buzzer

Parts:
B3: GND SCOPE; BANANA_MALE
B4: ADC SCOPE; BANANA_MALE
B5: DAC SCOPE; BANANA_MALE
C3: 0.1uf; C1206
S17, S18: STRIP5
S20, S24, S28, S50, S53, S58: STRIP10
SV9, SV10: MA03-1
U6: MAX4506; SOIC-8

Connections:
+5V: S17.P$1, S17.P$2, S17.P$3, S17.P$4, S17.P$5, S18.P$1, S18.P$2, S18.P$3, S18.P$4, S18.P$5; also elsewhere on the board
GND: B3.P$1, C3.2, S20.P$1, S20.P$2, S20.P$3, S20.P$4, S20.P$5, S20.P$6, S20.P$7, S20.P$8, S20.P$9, S20.P$10, S24.P$1, S24.P$2, S24.P$3, S24.P$4, S24.P$5, S24.P$6, S24.P$7, S24.P$8, S24.P$9, S24.P$10, S28.P$1, S28.P$2, S28.P$3, S28.P$4, S28.P$5, S28.P$6, S28.P$7, S28.P$8, S28.P$9, S28.P$10, U6.P$4 (V-); also elsewhere on the board
unnamed: SV9.1, U6.P$7 (OUT1)
unnamed: B5.P$1, SV9.2, U6.P$6 (OUT2)
unnamed: SV9.3, U6.P$5 (OUT3)
unnamed: B4.P$1, SV10.1, U6.P$1 (IN1)
unnamed: SV10.2, U6.P$2 (IN2)
unnamed: SV10.3, U6.P$3 (IN3)
VCC: C3.1, S50.P$1, S50.P$2, S50.P$3, S50.P$4, S50.P$5, S50.P$6, S50.P$7, S50.P$8, S50.P$9, S50.P$10, S53.P$1, S53.P$2, S53.P$3, S53.P$4, S53.P$5, S53.P$6, S53.P$7, S53.P$8, S53.P$9, S53.P$10, S58.P$1, S58.P$2, S58.P$3, S58.P$4, S58.P$5, S58.P$6, S58.P$7, S58.P$8, S58.P$9, S58.P$10, U6.P$8 (V+); also elsewhere on the board

Notes on the sheet:
ADC1_SIGNAL
ADC1_PROTECTED
DAC1_FROM28x
DAC1_TOSCOPE
SPARE_IN
SPARE_OUT

Parts:
C1, C12, C13, C15, C20, C25, C27, C28: 47uF; 153CLV-0810
C2, C14: 680pF; C1206
C16, C17, C22, C23: 0.1uF; C1206
C19, C24: 22nF; C1206
J4, J6, J23, J24: STRIP3
J78, J79, J80, J81, J82, J83, J84, J85, J86, J87, J196, J197, J198, J199, J200, J201, J202, J203: STRIP2
JP2, JP3: JP1E; JP1
R1, R2: R_B; 0207/10
R3, R7: 24.9K; M1206
R4, R5, R6, R8, R18, R24: 2.2K; M1206
R41, R43: 1.8K; M1206
R42, R44: 10K; M1206
S1, S159: SWITCH_SLIDE
S129, S130, S137, S138, S139, S147: STRIP5
SV1, SV3, SV7, SV8: MA03-2
T1, T2: TIP125; TO220
TRIMPOT1, TRIMPOT2: MA03-2
U1, U5: A4973; SO16W
U2, U4: DRV8874; HTSSOP16
U$2, U$3: GEARMOTOR_MOUNT

Connections:
+5V: J200.P$1, J200.P$2, J203.P$1, J203.P$2; also elsewhere on the board
A4973EN: S1.P$2 (P2), U1.8 (!ENABLE), U5.8 (!ENABLE)
DRV1_DIR: J80.P$1, J80.P$2, U2.P$2 (PH/IN2)
DRV1_M+: SV7.1, SV7.3, SV7.5, U2.P$8 (OUT1)
DRV1_M-: SV7.2, SV7.4, SV7.6, U2.P$10 (OUT2)
DRV1_PWM: J79.P$1, J79.P$2, U2.P$1 (EN/IN1)
DRV2_DIR: J83.P$1, J83.P$2, U4.P$2 (PH/IN2)
DRV2_M+: SV8.1, SV8.3, SV8.5, U4.P$8 (OUT1)
DRV2_M-: SV8.2, SV8.4, SV8.6, U4.P$10 (OUT2)
DRV2_PWM: J82.P$1, J82.P$2, U4.P$1 (EN/IN1)
GND: C1.-, C2.2, C12.-, C13.-, C14.2, C15.-, C16.2, C20.-, C22.2, C25.-, C27.-, C28.-, JP2.2, JP3.2, R3.1, R7.1, R41.2, R43.2, S1.P$1 (P1), S129.P$1, S129.P$2, S129.P$3, S129.P$4, S129.P$5, S137.P$1, S137.P$2, S137.P$3, S137.P$4, S137.P$5, S159.P$1 (P1), T1.3 (E), T2.3 (E), TRIMPOT1.5, TRIMPOT1.6, TRIMPOT2.5, TRIMPOT2.6, U1.4 (GND), U1.5 (GND), U1.11 (SENSE), U1.12 (GND), U1.13 (GND), U2.P$7 (IMODE), U2.P$9 (PGND), U2.P$15 (GND), U2.P$16 (PMODE), U2.P$17 (GND_PAD), U4.P$7 (IMODE), U4.P$9 (PGND), U4.P$15 (GND), U4.P$16 (PMODE), U4.P$17 (GND_PAD), U5.4 (GND), U5.5 (GND), U5.11 (SENSE), U5.12 (GND), U5.13 (GND); also elsewhere on the board
GPIO2: J198.P$1, J198.P$2; also elsewhere on the board
GPIO3: J199.P$1, J199.P$2; also elsewhere on the board
GPIO10: J84.P$1, J84.P$2; also elsewhere on the board
GPIO11: J86.P$1, J86.P$2; also elsewhere on the board
GPIO14: J201.P$1, J201.P$2; also elsewhere on the board
GPIO15: J202.P$1, J202.P$2; also elsewhere on the board
GPIO29: J85.P$1, J85.P$2; also elsewhere on the board
GPIO32: J87.P$1, J87.P$2; also elsewhere on the board
MENABLE: S159.P$2 (P2), U2.P$3 (NSLEEP), U4.P$3 (NSLEEP)
MOTOR1+: SV3.1, SV3.3, SV3.5, U1.15 (OUTB)
MOTOR1-: SV3.2, SV3.4, SV3.6, U1.10 (OUTA)
MOTOR2+: SV1.1, SV1.3, SV1.5, U5.15 (OUTB)
MOTOR2-: SV1.2, SV1.4, SV1.6, U5.10 (OUTA)
unnamed: R24.1, S1.P$3 (P3)
unnamed: S139.P$1, S139.P$2, S139.P$3, S139.P$4, S139.P$5
unnamed: S147.P$1, S147.P$2, S147.P$3, S147.P$4, S147.P$5
unnamed: R2.2, T2.1 (B)
unnamed: R1.2, T1.1 (B)
unnamed: S138.P$1, S138.P$2, S138.P$3, S138.P$4, S138.P$5
unnamed: R6.1, U5.1 (!BRAKE)
unnamed: C2.1, R7.2, U5.3 (RC)
unnamed: R8.1, U1.1 (!BRAKE)
unnamed: C14.1, R3.2, U1.3 (RC)
unnamed: JP2.1, R4.1, U1.14 (MODE)
unnamed: R18.1, S159.P$3 (P3)
unnamed: JP3.1, R5.1, U5.14 (MODE)
unnamed: C19.1, U2.P$14 (CPL)
unnamed: C19.2, U2.P$13 (CPH)
unnamed: C17.1, U2.P$12 (VCP)
unnamed: R43.1, U4.P$6 (IPROPI)
unnamed: R41.1, U2.P$6 (IPROPI)
unnamed: J78.P$1, J78.P$2, R42.2, U2.P$4 (NFAULT)
unnamed: TRIMPOT1.3, TRIMPOT1.4, U2.P$5 (VREF)
unnamed: C24.1, U4.P$14 (CPL)
unnamed: C24.2, U4.P$13 (CPH)
unnamed: C23.1, U4.P$12 (VCP)
unnamed: J81.P$1, J81.P$2, R44.2, U4.P$4 (NFAULT)
unnamed: TRIMPOT2.3, TRIMPOT2.4, U4.P$5 (VREF)
unnamed: S130.P$1, S130.P$2, S130.P$3, S130.P$4, S130.P$5
unnamed: J196.P$1, J196.P$2, U1.7 (PHASE)
unnamed: J197.P$1, J197.P$2, U5.7 (PHASE)
POWER: C1.+, C12.+, C13.+, C15.+, C16.1, C17.2, C20.+, C22.1, C23.2, C25.+, C27.+, C28.+, U1.9 (VBB), U1.16 (VBB), U2.P$11 (VM), U4.P$11 (VM), U5.9 (VBB), U5.16 (VBB); also elsewhere on the board
TR_BASE: J6.P$1, J6.P$2, J6.P$3, R1.1
TR_BASE1: J24.P$1, J24.P$2, J24.P$3, R2.1
TR_LOAD: J4.P$1, J4.P$2, J4.P$3, T1.2 (C)
TR_LOAD1: J23.P$1, J23.P$2, J23.P$3, T2.2 (C)
VCC: R4.2, R5.2, R6.2, R8.2, R18.2, R24.2, R42.1, R44.1, TRIMPOT1.1, TRIMPOT1.2, TRIMPOT2.1, TRIMPOT2.2, U1.2 (REF), U1.6 (VCC), U5.2 (REF), U5.6 (VCC); also elsewhere on the board

Notes on the sheet:
Pullups
RCSERVO
Only need to populate one of these 47uf
